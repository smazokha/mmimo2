options:
  parameters:
    author: stepanmazokha
    generate_options: qt_gui
    id: wifi_4usrp
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 60e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /root/usrp1_ant1.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /root/usrp1_ant2.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /root/usrp3_ant2.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /root/usrp5_ant2.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0_1
  id: blocks_file_sink
  parameters:
    file: /root/usrp7_ant2.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0_2
  id: blocks_file_sink
  parameters:
    file: /root/usrp2_ant2.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0_3
  id: blocks_file_sink
  parameters:
    file: /root/usrp4_ant2.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0_4
  id: blocks_file_sink
  parameters:
    file: /root/usrp6_ant2.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0_4_0
  id: blocks_file_sink
  parameters:
    file: /root/usrp8_ant2.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: /root/usrp3_ant1.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_1_0
  id: blocks_file_sink
  parameters:
    file: /root/usrp5_ant1.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_1_1
  id: blocks_file_sink
  parameters:
    file: /root/usrp7_ant1.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_1_2
  id: blocks_file_sink
  parameters:
    file: /root/usrp2_ant1.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_1_3
  id: blocks_file_sink
  parameters:
    file: /root/usrp4_ant1.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_1_4
  id: blocks_file_sink
  parameters:
    file: /root/usrp6_ant1.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_1_4_0
  id: blocks_file_sink
  parameters:
    file: /root/usrp8_ant1.bin
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: 2442e6
    center_freq1: 2442e6
    clock_source0: external
    dev_addr: '"10.10.23.11"'
    gain0: '30'
    nchan: '2'
    rx_agc1: Enabled
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: 2442e6
    center_freq1: 2442e6
    clock_source0: external
    dev_addr: '"10.10.23.13"'
    gain0: '30'
    nchan: '2'
    rx_agc1: Enabled
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: 2442e6
    center_freq1: 2442e6
    clock_source0: external
    dev_addr: '"10.10.23.15"'
    gain0: '30'
    nchan: '2'
    rx_agc1: Enabled
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: 2442e6
    center_freq1: 2442e6
    clock_source0: external
    dev_addr: '"10.10.23.17"'
    gain0: '30'
    nchan: '2'
    rx_agc1: Enabled
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0_0_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: 2442e6
    center_freq1: 2442e6
    clock_source0: external
    dev_addr: '"10.10.23.18"'
    gain0: '30'
    nchan: '2'
    rx_agc1: Enabled
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0_0_1
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: 2442e6
    center_freq1: 2442e6
    clock_source0: external
    dev_addr: '"10.10.23.16"'
    gain0: '30'
    nchan: '2'
    rx_agc1: Enabled
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0_1
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: 2442e6
    center_freq1: 2442e6
    clock_source0: external
    dev_addr: '"10.10.23.14"'
    gain0: '30'
    nchan: '2'
    rx_agc1: Enabled
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0_1
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: 2442e6
    center_freq1: 2442e6
    clock_source0: external
    dev_addr: '"10.10.23.12"'
    gain0: '30'
    nchan: '2'
    rx_agc1: Enabled
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '1', blocks_file_sink_0_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_file_sink_0_1, '0']
- [uhd_usrp_source_0_0, '1', blocks_file_sink_0_0_0, '0']
- [uhd_usrp_source_0_0_0, '0', blocks_file_sink_0_1_0, '0']
- [uhd_usrp_source_0_0_0, '1', blocks_file_sink_0_0_0_0, '0']
- [uhd_usrp_source_0_0_0_0, '0', blocks_file_sink_0_1_1, '0']
- [uhd_usrp_source_0_0_0_0, '1', blocks_file_sink_0_0_0_1, '0']
- [uhd_usrp_source_0_0_0_0_0, '0', blocks_file_sink_0_1_4_0, '0']
- [uhd_usrp_source_0_0_0_0_0, '1', blocks_file_sink_0_0_0_4_0, '0']
- [uhd_usrp_source_0_0_0_1, '0', blocks_file_sink_0_1_4, '0']
- [uhd_usrp_source_0_0_0_1, '1', blocks_file_sink_0_0_0_4, '0']
- [uhd_usrp_source_0_0_1, '0', blocks_file_sink_0_1_3, '0']
- [uhd_usrp_source_0_0_1, '1', blocks_file_sink_0_0_0_3, '0']
- [uhd_usrp_source_0_1, '0', blocks_file_sink_0_1_2, '0']
- [uhd_usrp_source_0_1, '1', blocks_file_sink_0_0_0_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
