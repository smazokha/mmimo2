options:
  parameters:
    generate_options: qt_gui
    id: RX_1
    output_language: python
    title: rx-1
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    bw0: ''
    bw1: ''
    center_freq0: 5.8e9
    center_freq1: 5.8e9
    clock_source0: external
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_addr: '"addr=10.10.23.12"'
    dev_args: '""'
    gain0: '30'
    gain1: '30'
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '1', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
