options:
  parameters:
    generate_options: qt_gui
    id: wifi_4usrp_native
    output_language: python
    title: mMIMO Capture
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 60e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /root/23-12_ch0.bin
    type: complex
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /root/23-12_ch1.bin
    type: complex
  states: {}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: /root/23-14_ch0.bin
    type: complex
  states: {}
- name: blocks_file_sink_3
  id: blocks_file_sink
  parameters:
    file: /root/23-14_ch1.bin
    type: complex
  states: {}
- name: blocks_file_sink_4
  id: blocks_file_sink
  parameters:
    file: /root/23-18_ch1.bin
    type: complex
  states: {}
- name: blocks_file_sink_5
  id: blocks_file_sink
  parameters:
    file: /root/23-16_ch0.bin
    type: complex
  states: {}
- name: blocks_file_sink_6
  id: blocks_file_sink
  parameters:
    file: /root/23-16_ch1.bin
    type: complex
  states: {}
- name: blocks_file_sink_7
  id: blocks_file_sink
  parameters:
    file: /root/23-18_ch0.bin
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: 2442e6
    dev_args: '""'
    gain0: '30'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    center_freq0: 2442e6
    center_freq1: 2442e6
    clock_source0: external
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_addr: '"addr=10.10.23.12"'
    dev_args: '""'
    gain0: '30'
    gain1: '30'
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    center_freq0: 2442e6
    center_freq1: 2442e6
    clock_source0: external
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_addr: '"addr=10.10.23.14"'
    dev_args: '""'
    gain0: '30'
    gain1: '30'
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0_1
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    center_freq0: 2442e6
    center_freq1: 2442e6
    clock_source0: external
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_addr: '"addr=10.10.23.16"'
    dev_args: '""'
    gain0: '30'
    gain1: '30'
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0_1_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    center_freq0: 2442e6
    center_freq1: 2442e6
    clock_source0: external
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_addr: '"addr=10.10.23.18"'
    dev_args: '""'
    gain0: '30'
    gain1: '30'
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', qtgui_freq_sink_x_1, '0']
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '1', blocks_file_sink_1, '0']
- [uhd_usrp_source_0_0, '0', blocks_file_sink_2, '0']
- [uhd_usrp_source_0_0, '1', blocks_file_sink_3, '0']
- [uhd_usrp_source_0_1, '0', blocks_file_sink_5, '0']
- [uhd_usrp_source_0_1, '1', blocks_file_sink_6, '0']
- [uhd_usrp_source_0_1_0, '0', blocks_file_sink_7, '0']
- [uhd_usrp_source_0_1_0, '1', blocks_file_sink_4, '0']

metadata:
  file_format: 1
