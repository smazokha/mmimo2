options:
  parameters:
    generate_options: qt_gui
    id: wifi_4usrp_native
    output_language: python
    title: mMIMO Capture
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 2442e6
  states: {}
- name: gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: record_num_items
  id: variable
  parameters:
    value: '5000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 60e6
  states: {}
- name: skip_num_items
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /root/24-1_chA.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /root/24-5_chA.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /root/24-5_chB.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: /root/24-1_chB.bin
    type: complex
  states: {}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: /root/24-2_chA.bin
    type: complex
  states: {}
- name: blocks_file_sink_2_0
  id: blocks_file_sink
  parameters:
    file: /root/24-6_chA.bin
    type: complex
  states: {}
- name: blocks_file_sink_2_1
  id: blocks_file_sink
  parameters:
    file: /root/24-2_chB.bin
    type: complex
  states: {}
- name: blocks_file_sink_3_0
  id: blocks_file_sink
  parameters:
    file: /root/24-6_chB.bin
    type: complex
  states: {}
- name: blocks_file_sink_4
  id: blocks_file_sink
  parameters:
    file: /root/24-4_chB.bin
    type: complex
  states: {}
- name: blocks_file_sink_4_0
  id: blocks_file_sink
  parameters:
    file: /root/24-8_chB.bin
    type: complex
  states: {}
- name: blocks_file_sink_5
  id: blocks_file_sink
  parameters:
    file: /root/24-3_chA.bin
    type: complex
  states: {}
- name: blocks_file_sink_5_0
  id: blocks_file_sink
  parameters:
    file: /root/24-7_chA.bin
    type: complex
  states: {}
- name: blocks_file_sink_6
  id: blocks_file_sink
  parameters:
    file: /root/24-3_chB.bin
    type: complex
  states: {}
- name: blocks_file_sink_6_0
  id: blocks_file_sink
  parameters:
    file: /root/24-7_chB.bin
    type: complex
  states: {}
- name: blocks_file_sink_7
  id: blocks_file_sink
  parameters:
    file: /root/24-4_chA.bin
    type: complex
  states: {}
- name: blocks_file_sink_7_0
  id: blocks_file_sink
  parameters:
    file: /root/24-8_chA.bin
    type: complex
  states: {}
- name: blocks_head_1
  id: blocks_head
  parameters:
    num_items: record_num_items
    type: complex
  states: {}
- name: blocks_head_1_0
  id: blocks_head
  parameters:
    num_items: record_num_items
    type: complex
  states: {}
- name: blocks_head_1_0_0
  id: blocks_head
  parameters:
    num_items: record_num_items
    type: complex
  states: {}
- name: blocks_head_1_1
  id: blocks_head
  parameters:
    num_items: record_num_items
    type: complex
  states: {}
- name: blocks_head_3
  id: blocks_head
  parameters:
    num_items: record_num_items
    type: complex
  states: {}
- name: blocks_head_3_0
  id: blocks_head
  parameters:
    num_items: record_num_items
    type: complex
  states: {}
- name: blocks_head_3_2
  id: blocks_head
  parameters:
    num_items: record_num_items
    type: complex
  states: {}
- name: blocks_head_4_0
  id: blocks_head
  parameters:
    num_items: record_num_items
    type: complex
  states: {}
- name: blocks_head_5
  id: blocks_head
  parameters:
    num_items: record_num_items
    type: complex
  states: {}
- name: blocks_head_5_0
  id: blocks_head
  parameters:
    num_items: record_num_items
    type: complex
  states: {}
- name: blocks_head_6
  id: blocks_head
  parameters:
    num_items: record_num_items
    type: complex
  states: {}
- name: blocks_head_6_0
  id: blocks_head
  parameters:
    num_items: record_num_items
    type: complex
  states: {}
- name: blocks_head_7
  id: blocks_head
  parameters:
    num_items: record_num_items
    type: complex
  states: {}
- name: blocks_head_7_0
  id: blocks_head
  parameters:
    num_items: record_num_items
    type: complex
  states: {}
- name: blocks_head_8
  id: blocks_head
  parameters:
    num_items: record_num_items
    type: complex
  states: {}
- name: blocks_head_8_0
  id: blocks_head
  parameters:
    num_items: record_num_items
    type: complex
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: skip_num_items
    type: complex
  states: {}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    num_items: skip_num_items
    type: complex
  states: {}
- name: blocks_skiphead_0_1
  id: blocks_skiphead
  parameters:
    num_items: skip_num_items
    type: complex
  states: {}
- name: blocks_skiphead_1_0
  id: blocks_skiphead
  parameters:
    num_items: skip_num_items
    type: complex
  states: {}
- name: blocks_skiphead_2
  id: blocks_skiphead
  parameters:
    num_items: skip_num_items
    type: complex
  states: {}
- name: blocks_skiphead_2_0
  id: blocks_skiphead
  parameters:
    num_items: skip_num_items
    type: complex
  states: {}
- name: blocks_skiphead_3
  id: blocks_skiphead
  parameters:
    num_items: skip_num_items
    type: complex
  states: {}
- name: blocks_skiphead_3_0
  id: blocks_skiphead
  parameters:
    num_items: skip_num_items
    type: complex
  states: {}
- name: blocks_skiphead_4
  id: blocks_skiphead
  parameters:
    num_items: skip_num_items
    type: complex
  states: {}
- name: blocks_skiphead_4_0
  id: blocks_skiphead
  parameters:
    num_items: skip_num_items
    type: complex
  states: {}
- name: blocks_skiphead_4_0_0
  id: blocks_skiphead
  parameters:
    num_items: skip_num_items
    type: complex
  states: {}
- name: blocks_skiphead_4_1
  id: blocks_skiphead
  parameters:
    num_items: skip_num_items
    type: complex
  states: {}
- name: blocks_skiphead_6
  id: blocks_skiphead
  parameters:
    num_items: skip_num_items
    type: complex
  states: {}
- name: blocks_skiphead_6_0
  id: blocks_skiphead
  parameters:
    num_items: skip_num_items
    type: complex
  states: {}
- name: blocks_skiphead_7
  id: blocks_skiphead
  parameters:
    num_items: skip_num_items
    type: complex
  states: {}
- name: blocks_skiphead_7_0
  id: blocks_skiphead
  parameters:
    num_items: skip_num_items
    type: complex
  states: {}
- name: qtgui_freq_sink_x_3
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_3_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_3_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_3_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    center_freq0: freq
    center_freq1: freq
    clock_source0: external
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_addr: '"addr=10.10.24.1"'
    dev_args: '""'
    gain0: gain
    gain1: gain
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sd_spec0: A:0 B:0
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    center_freq0: freq
    center_freq1: freq
    clock_source0: external
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_addr: '"addr=10.10.24.6"'
    dev_args: '""'
    gain0: gain
    gain1: gain
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0_1
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    center_freq0: freq
    center_freq1: freq
    clock_source0: external
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_addr: '"addr=10.10.24.3"'
    dev_args: '""'
    gain0: gain
    gain1: gain
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sd_spec0: A:0 B:0
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0_1_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    center_freq0: freq
    center_freq1: freq
    clock_source0: external
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_addr: '"addr=10.10.24.4"'
    dev_args: '""'
    gain0: gain
    gain1: gain
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sd_spec0: A:0 B:0
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0_1_0_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    center_freq0: freq
    center_freq1: freq
    clock_source0: external
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_addr: '"addr=10.10.24.8"'
    dev_args: '""'
    gain0: gain
    gain1: gain
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sd_spec0: A:0 B:0
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0_1_1
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    center_freq0: freq
    center_freq1: freq
    clock_source0: external
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_addr: '"addr=10.10.24.7"'
    dev_args: '""'
    gain0: gain
    gain1: gain
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sd_spec0: A:0 B:0
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0_2
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    center_freq0: freq
    center_freq1: freq
    clock_source0: external
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_addr: '"addr=10.10.24.5"'
    dev_args: '""'
    gain0: gain
    gain1: gain
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sd_spec0: A:0 B:0
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    center_freq0: freq
    center_freq1: freq
    clock_source0: external
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_addr: '"addr=10.10.24.2"'
    dev_args: '""'
    gain0: '0'
    gain1: '0'
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sd_spec0: A:0 B:0
    sync: sync
    time_source0: external
    type: fc32
  states: {}

connections:
- [blocks_head_1, '0', blocks_file_sink_0, '0']
- [blocks_head_1, '0', qtgui_freq_sink_x_3, '0']
- [blocks_head_1_0, '0', blocks_file_sink_0_0, '0']
- [blocks_head_1_0_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_head_1_1, '0', blocks_file_sink_0_1, '0']
- [blocks_head_1_1, '0', qtgui_freq_sink_x_3_0_0, '0']
- [blocks_head_3, '0', blocks_file_sink_2, '0']
- [blocks_head_3, '0', qtgui_freq_sink_x_3_0, '0']
- [blocks_head_3_0, '0', blocks_file_sink_2_0, '0']
- [blocks_head_3_2, '0', blocks_file_sink_2_1, '0']
- [blocks_head_3_2, '0', qtgui_freq_sink_x_3_0_1, '0']
- [blocks_head_4_0, '0', blocks_file_sink_3_0, '0']
- [blocks_head_5, '0', blocks_file_sink_7, '0']
- [blocks_head_5_0, '0', blocks_file_sink_7_0, '0']
- [blocks_head_6, '0', blocks_file_sink_5, '0']
- [blocks_head_6_0, '0', blocks_file_sink_5_0, '0']
- [blocks_head_7, '0', blocks_file_sink_6, '0']
- [blocks_head_7_0, '0', blocks_file_sink_6_0, '0']
- [blocks_head_8, '0', blocks_file_sink_4, '0']
- [blocks_head_8_0, '0', blocks_file_sink_4_0, '0']
- [blocks_skiphead_0, '0', blocks_head_3, '0']
- [blocks_skiphead_0_0, '0', blocks_head_3_0, '0']
- [blocks_skiphead_0_1, '0', blocks_head_3_2, '0']
- [blocks_skiphead_1_0, '0', blocks_head_4_0, '0']
- [blocks_skiphead_2, '0', blocks_head_5, '0']
- [blocks_skiphead_2_0, '0', blocks_head_5_0, '0']
- [blocks_skiphead_3, '0', blocks_head_8, '0']
- [blocks_skiphead_3_0, '0', blocks_head_8_0, '0']
- [blocks_skiphead_4, '0', blocks_head_1, '0']
- [blocks_skiphead_4_0, '0', blocks_head_1_0, '0']
- [blocks_skiphead_4_0_0, '0', blocks_head_1_0_0, '0']
- [blocks_skiphead_4_1, '0', blocks_head_1_1, '0']
- [blocks_skiphead_6, '0', blocks_head_6, '0']
- [blocks_skiphead_6_0, '0', blocks_head_6_0, '0']
- [blocks_skiphead_7, '0', blocks_head_7, '0']
- [blocks_skiphead_7_0, '0', blocks_head_7_0, '0']
- [uhd_usrp_source_0, '0', blocks_skiphead_4, '0']
- [uhd_usrp_source_0, '1', blocks_skiphead_4_1, '0']
- [uhd_usrp_source_0_0_0, '0', blocks_skiphead_0_0, '0']
- [uhd_usrp_source_0_0_0, '1', blocks_skiphead_1_0, '0']
- [uhd_usrp_source_0_1, '0', blocks_skiphead_6, '0']
- [uhd_usrp_source_0_1, '1', blocks_skiphead_7, '0']
- [uhd_usrp_source_0_1_0, '0', blocks_skiphead_2, '0']
- [uhd_usrp_source_0_1_0, '1', blocks_skiphead_3, '0']
- [uhd_usrp_source_0_1_0_0, '0', blocks_skiphead_2_0, '0']
- [uhd_usrp_source_0_1_0_0, '1', blocks_skiphead_3_0, '0']
- [uhd_usrp_source_0_1_1, '0', blocks_skiphead_6_0, '0']
- [uhd_usrp_source_0_1_1, '1', blocks_skiphead_7_0, '0']
- [uhd_usrp_source_0_2, '0', blocks_skiphead_4_0, '0']
- [uhd_usrp_source_0_2, '1', blocks_skiphead_4_0_0, '0']
- [uhd_usrp_source_1, '0', blocks_skiphead_0, '0']
- [uhd_usrp_source_1, '1', blocks_skiphead_0_1, '0']

metadata:
  file_format: 1
